# Keil uVision project Project_13.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project_13 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c Key.c Key.h Nixie_tube.c Nixie_tube.h Timer0.c Timer0.h Delay1ms.c Delay1ms.h
