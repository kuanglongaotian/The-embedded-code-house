# Keil uVision project Project_4.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project_4 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c MatrixKey.c MatrixKey.h Delay1ms.c Delay1ms.h LCD1602.c LCD1602.h
