# Keil uVision project Project_12.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project_12 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c LCD1602.c LCD1602.h Delay1ms.c Delay1ms.h One_wire.c One_wire.h DS18B20.c DS18B20.h AT24C02.c AT24C02.h Key.c Key.h I2c.c I2c.h
